options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: framsat1
    output_language: python
    title: framsat1
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: '2500000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_x_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Block for GNU Radio: consumes deframed AX.25/FS1.0 PDUs
      (from gr-satellites' AX.25 Deframer, or your own custom deframer) on its
      'pdu' message input, and prints decoded FramSat-1 telemetry.

      Parsing logic ported verbatim from framsat1_iq_decoder.py, which was
      verified byte-for-byte against the real repo's framsat1_decoder.py and
      against a ground-truth framsat1.kss capture.

      Optional log_file constructor parameter (shows up as a block property in
      GRC's properties dialog automatically): if set to a path, every frame's
      exact console output is also appended to that file, flushed immediately.
      Leave it blank ('') for console-only output (the original behavior).
      """

      import struct
      from datetime import datetime, timezone

      import pmt
      from gnuradio import gr

      SIGNATURE = b"FS1.0"
      EXPECTED_CALLSIGN = "LA1ORB"
      HEALTH_FMT = ">5sBBBHBHHI"
      HEALTH_SIZE = struct.calcsize(HEALTH_FMT)
      SENSOR_SAMPLE_FMT = ">BHHHHBBBBBHI"
      SENSOR_SAMPLE_SIZE = struct.calcsize(SENSOR_SAMPLE_FMT)


      def parse_fs1_telemetry(payload):
          if len(payload) < HEALTH_SIZE:
              return None
          sign, bcn_id, bcn_type, rssi, cmd_count, eps_flags, reboots, v_mv, uptime = \
              struct.unpack(HEALTH_FMT, payload[:HEALTH_SIZE])
          result = {
              "signature": sign.decode("ascii", errors="replace"),
              "beacon_id": bcn_id,
              "operating_mode": "LEOP (Launch / Deployment Mode)" if bcn_type == 2 else "DEFAULT (Nominal Orbit)",
              "satellite_uplink_rssi": f"-{rssi} dBm" if rssi > 0 else "N/A (No uplink signal received)",
              "telecommands_accepted": cmd_count,
              "eps_flags": f"0x{eps_flags:02X}",
              "reboot_count": reboots,
              "battery_voltage_v": v_mv / 1000.0,
              "battery_voltage_mv": v_mv,
              "uptime_sec": uptime,
              "uptime_hours": uptime / 3600.0,
          }
          raw_sensors = payload[HEALTH_SIZE:-4] if len(payload) >= HEALTH_SIZE + 4 else payload[HEALTH_SIZE:]
          trailer = payload[-4:] if len(payload) >= HEALTH_SIZE + 4 else b""
          result["trailer_hex"] = trailer.hex().upper()
          if bcn_type == 2 and all(b == 0 for b in raw_sensors):
              result["sensor_status"] = f"Sensors unpowered during deployment ({len(raw_sensors)} bytes zero-padded)."
              result["sensors"] = []
              return result
          sensors = []
          n_samples = len(raw_sensors) // SENSOR_SAMPLE_SIZE
          for i in range(min(n_samples, 9)):
              chunk = raw_sensors[i * SENSOR_SAMPLE_SIZE:(i + 1) * SENSOR_SAMPLE_SIZE]
              if len(chunk) == SENSOR_SAMPLE_SIZE:
                  s_id, g_a, g_b, g_c, g_d, e_x, e_y, i1, i2, i3, s_size, s_time = \
                      struct.unpack(SENSOR_SAMPLE_FMT, chunk)
                  sensors.append({"sample": i + 1, "time_s": s_time, "gss": (g_a, g_b, g_c, g_d),
                                   "ess_xy": (e_x, e_y), "ess_illum": (i1, i2, i3)})
          result["sensors"] = sensors
          result["sensor_status"] = None
          return result


      def format_decoded_frame(payload):
          """Builds the full display text for one frame as a single string
          (used for both console printing and file logging, guaranteeing they
          are always byte-for-byte identical to each other)."""
          lines = []

          def emit(s=""):
              lines.append(s)

          ts_str = datetime.now(timezone.utc).strftime("%Y-%m-%d %H:%M:%S") + " UTC"
          emit("\n" + "=" * 65)
          emit(f"\U0001F6F0\uFE0F  FramSat-1 Frame Received at {ts_str}")
          emit(f"   Total Frame Length: {len(payload)} bytes")

          idx = payload.find(SIGNATURE)
          if idx == -1:
              emit(f"   Payload Raw Hex:    {payload.hex().upper()}")
              emit("=" * 65 + "\n")
              return "\n".join(lines) + "\n"

          emit(f"   Telemetry Found:    Offset index {idx}")
          if idx >= 16:
              dest_call = "".join(chr(b >> 1) for b in payload[0:6]).strip()
              src_call = "".join(chr(b >> 1) for b in payload[7:13]).strip()
              emit(f"   Encapsulation:      AX.25 UI-Frame ({src_call} -> {dest_call})")
              emit(f"   Source:             {src_call} (Expected: {EXPECTED_CALLSIGN})")
          elif idx > 0:
              emit(f"   Transport Header:   {payload[:idx].hex().upper()} ({idx} bytes)")
          else:
              emit("   Encapsulation:      Direct HDLC (Payload starts at offset 0)")

          tlm = parse_fs1_telemetry(payload[idx:])
          if tlm is None:
              emit(f"   Payload Raw Hex: {payload[idx:].hex().upper()}")
              emit("=" * 65 + "\n")
              return "\n".join(lines) + "\n"

          emit("\n   \u2500\u2500\u2500 [ FramSat-1 Housekeeping Telemetry ] \u2500\u2500\u2500")
          emit(f"   Signature:             {tlm['signature']}")
          emit(f"   Beacon ID:             #{tlm['beacon_id']}")
          emit(f"   Operating Mode:        {tlm['operating_mode']}")
          emit(f"   Satellite Uplink RSSI: {tlm['satellite_uplink_rssi']}")
          emit(f"   Telecommands Accepted: {tlm['telecommands_accepted']}")
          emit(f"   EPS Flags:             {tlm['eps_flags']}")
          emit(f"   OBC / EPS Reboot Count:{tlm['reboot_count']}")
          emit(f"   Battery Voltage:       {tlm['battery_voltage_v']:.3f} V ({tlm['battery_voltage_mv']} mV)")
          emit(f"   Satellite Uptime:      {tlm['uptime_sec']} s ({tlm['uptime_hours']:.2f} hours)")

          if tlm["sensor_status"]:
              emit(f"\n   \u2500\u2500\u2500 [ Attitude Sensors (LEOP Mode) ] \u2500\u2500\u2500")
              emit(f"   Status:               {tlm['sensor_status']}")
          elif tlm["sensors"]:
              emit(f"\n   \u2500\u2500\u2500 [ Attitude Sensors: {len(tlm['sensors'])}x Samples ] \u2500\u2500\u2500")
              emit("   # | Time (s)    | Sun Sensor GSS (a, b, c, d)            | Earth Sensor ESS (x, y, illum)")
              emit("  ───+─────────────+────────────────────────────────────────+───────────────────────────────")
              for s in tlm["sensors"]:
                  g_a, g_b, g_c, g_d = s["gss"]
                  e_x, e_y = s["ess_xy"]
                  i1, i2, i3 = s["ess_illum"]
                  gss_str = f"{g_a:5d}, {g_b:5d}, {g_c:5d}, {g_d:5d}"
                  ess_str = f"X={e_x:3d}, Y={e_y:3d}, Illum=[{i1},{i2},{i3}]"
                  emit(f"   {s['sample']:1d} | {s['time_s']:<11d} | {gss_str:<38s} | {ess_str}")

          emit("=" * 65 + "\n")
          return "\n".join(lines) + "\n"


      class blk(gr.basic_block):
          """FS1.0 Telemetry Sink -- message-only block, no stream I/O.

          log_file: optional path (GRC block parameter). If non-empty, every
          frame's output is also appended there, flushed immediately -- useful
          for keeping a guaranteed-plain-text record independent of whatever is
          capturing/rendering the console (screenshots, GUI consoles, etc. can
          all mis-render monospace text; a file opened later in any genuinely
          monospace viewer settles that).
          """

          def __init__(self, log_file=""):
              gr.basic_block.__init__(self, name="FS1.0 Telemetry Sink", in_sig=[], out_sig=[])
              self.message_port_register_in(pmt.intern("pdu"))
              self.set_msg_handler(pmt.intern("pdu"), self.handle_msg)
              self._log_fh = open(log_file, "a", encoding="utf-8") if log_file else None

          def handle_msg(self, msg):
              try:
                  payload = bytes(pmt.u8vector_elements(pmt.cdr(msg)))
              except Exception:
                  return
              text = format_decoded_frame(payload)
              print(text, end="")
              if self._log_fh is not None:
                  self._log_fh.write(text)
                  self._log_fh.flush()

          def stop(self):
              if self._log_fh is not None:
                  self._log_fh.close()
                  self._log_fh = None
              return True
    comment: 'Fully self-contained: this block''s code is embedded directly in this .grc file (not pasted in separately), so opening this file in GRC always gives the current, verified FS1.0 parsing/printing logic -- no separate copy-paste step to go stale.'
    log_file: '"/home/bob/framsat1_log5.txt"'
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/IQ_Files/
    basefile: framsat1
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: bool(record_iq)
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '435141000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4531'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: '435141000'
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: NOTE SSDV
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '20'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: record_iq
  id: parameter
  parameters:
    label: record_iq
    type: intx
    value: '0'
  states: {}
- name: rig_freq_poller_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time, socket
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, rig_host='127.0.0.1', rig_port=4532, poll_interval_s=0.5):
              gr.basic_block.__init__(self, name='rig_freq_poller', in_sig=None, out_sig=None)
              self.message_port_register_out(pmt.intern('freq'))
              self.rig_host = rig_host
              self.rig_port = rig_port
              self.poll_interval_s = poll_interval_s
              self._stop = threading.Event()
              self._thread = threading.Thread(target=self._loop, daemon=True)

          def start(self):
              self._thread.start()
              return True

          def stop(self):
              self._stop.set()
              return True

          def _loop(self):
              sock = None
              last = None
              while not self._stop.is_set():
                  try:
                      if sock is None:
                          sock = socket.create_connection((self.rig_host, self.rig_port), timeout=2)
                      sock.sendall(b'f\n')
                      freq = float(sock.recv(64).decode().strip())
                      if freq != last:
                          last = freq
                          self.message_port_pub(pmt.intern('freq'),
                                                 pmt.cons(pmt.intern('freq'), pmt.from_double(freq)))
                  except (OSError, ValueError):
                      sock = None
                  time.sleep(self.poll_interval_s)
    poll_interval_s: '0.5'
    rig_host: '''127.0.0.1'''
    rig_port: '4531'
  states: {}
- name: satellites_ax25_deframer_0_0
  id: satellites_ax25_deframer
  parameters:
    g3ruh_scrambler: 'True'
  states: {}
- name: satellites_fsk_demodulator_0
  id: satellites_fsk_demodulator
  parameters:
    baudrate: '9600'
    iq: 'True'
    samp_rate: '50000'
    subaudio: 'False'
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/framsat1b.kss
  states: {}
- name: satellites_pdu_length_filter_0
  id: satellites_pdu_length_filter
  parameters:
    max: '250'
    min: '175'
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_telemetry_submit_0
  id: satellites_telemetry_submit
  parameters:
    norad: '98914'
    server: '"SatNOGS"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_x_0, '1']
- [blocks_multiply_x_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', satellites_fsk_demodulator_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_x_0, '0']
- [rig_freq_poller_0, freq, gpredict_MsgPairToVar_0, inpair]
- [satellites_ax25_deframer_0_0, out, satellites_pdu_length_filter_0, in]
- [satellites_fsk_demodulator_0, '0', satellites_ax25_deframer_0_0, '0']
- [satellites_pdu_length_filter_0, out, satellites_kiss_file_sink_0, in]
- [satellites_pdu_length_filter_0, out, satellites_print_timestamp_0, in]
- [satellites_pdu_length_filter_0, out, satellites_telemetry_submit_0, in]
- [satellites_print_timestamp_0, out, epy_block_0_0, pdu]

metadata:
  file_format: 1
  grc_version: 3.10.9.2

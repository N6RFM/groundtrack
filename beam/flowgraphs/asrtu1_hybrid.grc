options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: asrtu1_hybrid
    output_language: python
    title: asrtu1_hybrid
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-15000'
    step: '100'
    stop: '15000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.5e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: '2500000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: +(810000)
    offset: '0'
    phase: '0'
    samp_rate: '2500000'
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_x_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_x_1
  id: blocks_multiply_xx
  parameters:
    comment: output is 435.4 MHz
    type: complex
  states: {}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/IQ_Files/
    basefile: ASRTU-1_beam_SSDV
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: bool(record_iq)
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: filerepeater_AdvFileSink_1
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/IQ_Files/
    basefile: ASRTU-1_beam_TELEM
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq-810000
    recordOnStart: bool(record_iq)
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '436210000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: gpredict_port
  id: parameter
  parameters:
    label: GPredict port
    type: intx
    value: '4531'
  states: {}
- name: lilacsat_attach_preamble_and_tailer_0
  id: lilacsat_attach_preamble_and_tailer
  parameters:
    comment: gr-lilacsat
    len_preamble: '0'
    len_tailer: '0'
    padding_type: 'False'
  states: {}
- name: lilacsat_attach_preamble_and_tailer_1
  id: lilacsat_attach_preamble_and_tailer
  parameters:
    comment: gr-lilacsat
    len_preamble: '0'
    len_tailer: '0'
    padding_type: 'False'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    comment: To ASRTU SSDV Image Viewer connecting on 19986 using tcp_bridge
    host: 127.0.0.1
    mtu: '10000'
    port: '9986'
    type: TCP_SERVER
  states: {}
- name: network_socket_pdu_1
  id: network_socket_pdu
  parameters:
    comment: To ASRTU SSDV local telemetry decoder connecting on 19985 using tcp_bridge
    host: 127.0.0.1
    mtu: '10000'
    port: '9985'
    type: TCP_SERVER
  states: {}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: '436210000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: NOTE SSDV
  states: {}
- name: note_0_1
  id: note
  parameters:
    note: NOTE TELEM
  states: {}
- name: note_1
  id: note
  parameters:
    note: telem
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0
    bb_gain0: '20'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: record_iq
  id: parameter
  parameters:
    label: record_iq
    type: intx
    value: '1'
  states: {}
- name: record_iq_0
  id: parameter
  parameters:
    label: record_iq
    type: intx
    value: '1'
  states: {}
- name: rig_freq_poller_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time, socket
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, rig_host='127.0.0.1', rig_port=4532, poll_interval_s=0.5):
              gr.basic_block.__init__(self, name='rig_freq_poller', in_sig=None, out_sig=None)
              self.message_port_register_out(pmt.intern('freq'))
              self.rig_host = rig_host
              self.rig_port = rig_port
              self.poll_interval_s = poll_interval_s
              self._stop = threading.Event()
              self._thread = threading.Thread(target=self._loop, daemon=True)

          def start(self):
              self._thread.start()
              return True

          def stop(self):
              self._stop.set()
              return True

          def _loop(self):
              sock = None
              last = None
              while not self._stop.is_set():
                  try:
                      if sock is None:
                          sock = socket.create_connection((self.rig_host, self.rig_port), timeout=2)
                      sock.sendall(b'f\n')
                      freq = float(sock.recv(64).decode().strip())
                      if freq != last:
                          last = freq
                          self.message_port_pub(pmt.intern('freq'),
                                                 pmt.cons(pmt.intern('freq'), pmt.from_double(freq)))
                  except (OSError, ValueError):
                      sock = None
                  time.sleep(self.poll_interval_s)
    poll_interval_s: '0.5'
    rig_host: '''127.0.0.1'''
    rig_port: '4531'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_hexdump_sink_1
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/KSS_Files/ASRTU1_SSDV.kss
  states: {}
- name: satellites_kiss_file_sink_1
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/KSS_Files/ASRTU1_TELEM.kss
  states: {}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_print_timestamp_1
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/bob/gr-satellites/python/satyaml/ASRTU-1.yml
    iq: 'True'
    norad: '49272'
    options: ''
    samp_rate: '50000'
  states: {}
- name: satellites_satellite_decoder_1
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/bob/gr-satellites/python/satyaml/ASRTU-1.yml
    iq: 'True'
    norad: '49272'
    options: ''
    samp_rate: '50000'
  states: {}
- name: satellites_telemetry_submit_1
  id: satellites_telemetry_submit
  parameters:
    norad: '61781'
    server: '"SatNOGS"'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    comment: 436.21 MHz out at 2.5M sps/bw
    stream_id: totelem
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    comment: |-
      input is already doppler corrected

      436.21 MHz in at 2.5M sps/bw

      Target for telemetry is 435.400 MHz
    stream_id: totelem
  states: {}
- name: zeromq_pub_msg_sink_0
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5556
    comment: Local Address to ssdv proxy  :5556
    timeout: '1000'
  states: {}
- name: zeromq_pub_msg_sink_1
  id: zeromq_pub_msg_sink
  parameters:
    address: tcp://127.0.0.1:5555
    comment: Telemetry to proxy  :5555
    timeout: '1000'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_x_0, '1']
- [analog_sig_source_x_1, '0', blocks_multiply_x_1, '1']
- [blocks_multiply_x_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_x_0, '0', virtual_sink_0, '0']
- [blocks_multiply_x_1, '0', low_pass_filter_1, '0']
- [lilacsat_attach_preamble_and_tailer_0, out, network_socket_pdu_0, pdus]
- [lilacsat_attach_preamble_and_tailer_0, out, zeromq_pub_msg_sink_0, in]
- [lilacsat_attach_preamble_and_tailer_1, out, network_socket_pdu_1, pdus]
- [lilacsat_attach_preamble_and_tailer_1, out, zeromq_pub_msg_sink_1, in]
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', satellites_satellite_decoder_0, '0']
- [low_pass_filter_1, '0', filerepeater_AdvFileSink_1, '0']
- [low_pass_filter_1, '0', satellites_satellite_decoder_1, '0']
- [osmosdr_source_0, '0', blocks_multiply_x_0, '0']
- [rig_freq_poller_0, freq, gpredict_MsgPairToVar_0, inpair]
- [satellites_print_timestamp_0, out, satellites_hexdump_sink_0, in]
- [satellites_print_timestamp_1, out, satellites_hexdump_sink_1, in]
- [satellites_satellite_decoder_0, out, lilacsat_attach_preamble_and_tailer_0, in]
- [satellites_satellite_decoder_0, out, satellites_kiss_file_sink_0, in]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]
- [satellites_satellite_decoder_1, out, lilacsat_attach_preamble_and_tailer_1, in]
- [satellites_satellite_decoder_1, out, satellites_kiss_file_sink_1, in]
- [satellites_satellite_decoder_1, out, satellites_print_timestamp_1, in]
- [satellites_satellite_decoder_1, out, satellites_telemetry_submit_1, in]
- [virtual_source_0, '0', blocks_multiply_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2

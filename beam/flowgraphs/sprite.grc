options:
  parameters:
    author: N6RFM
    generate_options: qt_gui
    id: sprite
    output_language: python
    title: sprite
  states: {}

blocks:
- name: BFO
  id: variable_qtgui_range
  parameters:
    start: '-5000'
    step: '100'
    stop: '5000'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2500000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-(freq-nfreq+offset)+BFO'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_multiply_x_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      embedded python block: kiss_encode_pdu

      Wraps each incoming PDU in real KISS framing (FEND + command byte +
      escaped payload + FEND) before handing it to network_socket_pdu.

      network_socket_pdu is a generic GNU Radio core block with no knowledge
      of KISS - it just writes whatever PDU bytes it's given straight to the
      socket. satellites_kiss_file_sink applies KISS framing internally when
      writing to a file, which is why every .kss file this station has ever
      produced parses correctly - but nothing was applying that same framing
      on the live TCP path, so downstream every PDU arrived as an unframed
      blob with no 0xC0 delimiter for SatsDecoder's kiss_read_stream() to
      find. Multiple PDUs arriving close together (e.g. during an image
      burst) then get coalesced by TCP into one recv() with no way to tell
      where one frame ends and the next begins.

      Insert this block between satellites_satellite_decoder_0's "out" port
      and network_socket_pdu_0's "pdus" input (remove the direct connection,
      route through this block instead). No other wiring changes needed.
      """

      import numpy as np
      from gnuradio import gr
      import pmt

      FEND = 0xC0
      FESC = 0xDB
      TFEND = 0xDC
      TFESC = 0xDD


      def kiss_escape(data: bytes) -> bytes:
          out = bytearray()
          for b in data:
              if b == FESC:
                  out.append(FESC)
                  out.append(TFESC)
              elif b == FEND:
                  out.append(FESC)
                  out.append(TFEND)
              else:
                  out.append(b)
          return bytes(out)


      class blk(gr.sync_block):
          """Wrap each PDU in KISS framing (FEND + cmd byte + escaped data + FEND)"""

          def __init__(self, kiss_command=0x00):
              gr.sync_block.__init__(
                  self,
                  name='kiss_encode_pdu',
                  in_sig=None,
                  out_sig=None,
              )
              self.kiss_command = kiss_command
              self.message_port_register_in(pmt.intern('in'))
              self.set_msg_handler(pmt.intern('in'), self.handle_msg)
              self.message_port_register_out(pmt.intern('out'))

          def handle_msg(self, msg):
              try:
                  if pmt.is_pair(msg):
                      data_pmt = pmt.cdr(msg)
                  else:
                      data_pmt = msg
                  payload = bytes(bytearray(pmt.u8vector_elements(data_pmt)))
              except Exception as e:
                  print(f"[kiss_encode_pdu] could not extract PDU bytes: {e}")
                  return

              framed = bytes([FEND, self.kiss_command]) + kiss_escape(payload) + bytes([FEND])
              out_vec = pmt.init_u8vector(len(framed), list(framed))
              self.message_port_pub(pmt.intern('out'), pmt.cons(pmt.PMT_NIL, out_vec))
    kiss_command: '0'
  states: {state: disabled}
- name: filerepeater_AdvFileSink_0
  id: filerepeater_AdvFileSink
  parameters:
    autostartFreqChange: 'False'
    basedir: /home/bob/Desktop/IQ_Files/
    basefile: sprite
    bits_per_sample: '8'
    honorFreqChange: 'False'
    honorFreqTags: 'False'
    maxSize: '0'
    maxTimeSec: '0'
    radioCenterFreq: freq
    recordOnStart: bool(record_iq)
    sampleRate: '50000'
    type: complex
    unbuffered: 'False'
    vlen: '1'
  states: {}
- name: freq
  id: parameter
  parameters:
    label: frequency
    short_id: f
    type: eng_float
    value: '437325000'
  states: {}
- name: gpredict_MsgPairToVar_0
  id: gpredict_MsgPairToVar
  parameters:
    target: freq
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '25000'
    decim: '50'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '600'
    win: window.WIN_HAMMING
  states: {}
- name: network_socket_pdu_0
  id: network_socket_pdu
  parameters:
    host: '''127.0.0.1'''
    mtu: '10000'
    port: '9105'
    tcp_no_delay: 'True'
    type: TCP_CLIENT
  states: {state: disabled}
- name: nfreq
  id: parameter
  parameters:
    label: Nominal Frequency
    type: eng_float
    value: '437325000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: Doppler via shared rigctld on port 4532 (see rig_freq_poller_0)
  states: {}
- name: note_1
  id: note
  parameters:
    note: Required for Satsdecoder downstream
  states: {}
- name: offset
  id: parameter
  parameters:
    label: centre frequency offset
    type: eng_float
    value: 50e3
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: driver=airspy,serial=466c64c8323184c7,soapy=0,bitpack=false
    bb_gain0: '20'
    biast: 'False'
    freq0: nfreq-offset
    gain0: '20'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: record_iq
  id: parameter
  parameters:
    comment: record IQ on this run? 1 = yes, 0 = no
    label: record_iq
    type: intx
    value: '1'
  states: {}
- name: rig_freq_poller_0
  id: epy_block
  parameters:
    _source_code: |
      import threading, time, socket
      from gnuradio import gr
      import pmt

      class blk(gr.basic_block):
          def __init__(self, rig_host='127.0.0.1', rig_port=4532, poll_interval_s=0.5):
              gr.basic_block.__init__(self, name='rig_freq_poller', in_sig=None, out_sig=None)
              self.message_port_register_out(pmt.intern('freq'))
              self.rig_host = rig_host
              self.rig_port = rig_port
              self.poll_interval_s = poll_interval_s
              self._stop = threading.Event()
              self._thread = threading.Thread(target=self._loop, daemon=True)

          def start(self):
              self._thread.start()
              return True

          def stop(self):
              self._stop.set()
              return True

          def _loop(self):
              sock = None
              last = None
              while not self._stop.is_set():
                  try:
                      if sock is None:
                          sock = socket.create_connection((self.rig_host, self.rig_port), timeout=2)
                      sock.sendall(b'f\n')
                      freq = float(sock.recv(64).decode().strip())
                      if freq != last:
                          last = freq
                          self.message_port_pub(pmt.intern('freq'),
                                                 pmt.cons(pmt.intern('freq'), pmt.from_double(freq)))
                  except (OSError, ValueError):
                      sock = None
                  time.sleep(self.poll_interval_s)
    poll_interval_s: '0.5'
    rig_host: '''127.0.0.1'''
    rig_port: '4531'
  states: {}
- name: satellites_hexdump_sink_0
  id: satellites_hexdump_sink
  parameters: {}
  states: {}
- name: satellites_kiss_file_sink_0
  id: satellites_kiss_file_sink
  parameters:
    append: 'True'
    file: /home/bob/Desktop/KSS_Files/sprite.kss
  states: {}
- name: satellites_kiss_server_sink_0
  id: satellites_kiss_server_sink
  parameters:
    address: 127.0.0.1
    port: '8100'
  states: {state: disabled}
- name: satellites_print_timestamp_0
  id: satellites_print_timestamp
  parameters:
    count: 'True'
    fmt: '%Y-%m-%d %H:%M:%S'
  states: {}
- name: satellites_satellite_decoder_0
  id: satellites_satellite_decoder
  parameters:
    definition: file
    file: /home/bob/Desktop/modified satyaml/SPRITE.yml
    iq: 'True'
    norad: '64891'
    options: ''
    samp_rate: '50000'
  states: {}
- name: satellites_telemetry_submit_0
  id: satellites_telemetry_submit
  parameters:
    norad: '99299'
    server: '"SatNOGS"'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_x_0, '1']
- [blocks_multiply_x_0, '0', low_pass_filter_0, '0']
- [epy_block_0, out, network_socket_pdu_0, pdus]
- [low_pass_filter_0, '0', filerepeater_AdvFileSink_0, '0']
- [low_pass_filter_0, '0', satellites_satellite_decoder_0, '0']
- [osmosdr_source_0, '0', blocks_multiply_x_0, '0']
- [rig_freq_poller_0, freq, gpredict_MsgPairToVar_0, inpair]
- [satellites_print_timestamp_0, out, satellites_hexdump_sink_0, in]
- [satellites_satellite_decoder_0, out, epy_block_0, in]
- [satellites_satellite_decoder_0, out, satellites_kiss_file_sink_0, in]
- [satellites_satellite_decoder_0, out, satellites_print_timestamp_0, in]
- [satellites_satellite_decoder_0, out, satellites_telemetry_submit_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
